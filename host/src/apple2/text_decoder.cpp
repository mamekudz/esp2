#include "esp_bracket/text_decoder.hpp"

#include <cstring>

namespace esp_bracket {

namespace {

// Project-owned 5×7 glyphs for printable ASCII 0x20–0x5F (uppercase + punct).
// Each glyph: 7 rows, 5 LSBits used. NOT from Apple character ROM.
const uint8_t kGlyphs[64][7] = {
    // space
    {0, 0, 0, 0, 0, 0, 0},
    // ! " # $ % & ' ( ) * + , - . /
    {0x04, 0x04, 0x04, 0x04, 0x00, 0x04, 0x00},
    {0x0A, 0x0A, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x0A, 0x1F, 0x0A, 0x1F, 0x0A, 0x00, 0x00},
    {0x04, 0x0F, 0x14, 0x0E, 0x05, 0x1E, 0x04},
    {0x19, 0x19, 0x02, 0x04, 0x08, 0x13, 0x13},
    {0x08, 0x14, 0x14, 0x08, 0x15, 0x12, 0x0D},
    {0x04, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x02, 0x04, 0x08, 0x08, 0x08, 0x04, 0x02},
    {0x08, 0x04, 0x02, 0x02, 0x02, 0x04, 0x08},
    {0x00, 0x0A, 0x04, 0x1F, 0x04, 0x0A, 0x00},
    {0x00, 0x04, 0x04, 0x1F, 0x04, 0x04, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x04, 0x04, 0x08},
    {0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00},
    {0x01, 0x02, 0x04, 0x08, 0x10, 0x00, 0x00},
    // 0-9
    {0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E},
    {0x04, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x0E},
    {0x0E, 0x11, 0x01, 0x06, 0x08, 0x10, 0x1F},
    {0x1F, 0x01, 0x02, 0x06, 0x01, 0x11, 0x0E},
    {0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02},
    {0x1F, 0x10, 0x1E, 0x01, 0x01, 0x11, 0x0E},
    {0x06, 0x08, 0x10, 0x1E, 0x11, 0x11, 0x0E},
    {0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08},
    {0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E},
    {0x0E, 0x11, 0x11, 0x0F, 0x01, 0x02, 0x0C},
    // : ; < = > ?
    {0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00},
    {0x00, 0x04, 0x00, 0x00, 0x04, 0x04, 0x08},
    {0x02, 0x04, 0x08, 0x10, 0x08, 0x04, 0x02},
    {0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00},
    {0x08, 0x04, 0x02, 0x01, 0x02, 0x04, 0x08},
    {0x0E, 0x11, 0x01, 0x02, 0x04, 0x00, 0x04},
    // @ A-Z (map '@' and A-Z)
    {0x0E, 0x11, 0x17, 0x15, 0x17, 0x10, 0x0E},
    {0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}, // A
    {0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E},
    {0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E},
    {0x1C, 0x12, 0x11, 0x11, 0x11, 0x12, 0x1C},
    {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F},
    {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10},
    {0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0F},
    {0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11},
    {0x0E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E},
    {0x01, 0x01, 0x01, 0x01, 0x11, 0x11, 0x0E},
    {0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11},
    {0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F},
    {0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11},
    {0x11, 0x19, 0x15, 0x13, 0x11, 0x11, 0x11},
    {0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E},
    {0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10},
    {0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D},
    {0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11},
    {0x0E, 0x11, 0x10, 0x0E, 0x01, 0x11, 0x0E},
    {0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04},
    {0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E},
    {0x11, 0x11, 0x11, 0x11, 0x11, 0x0A, 0x04},
    {0x11, 0x11, 0x11, 0x15, 0x15, 0x1B, 0x11},
    {0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11},
    {0x11, 0x11, 0x0A, 0x04, 0x04, 0x04, 0x04},
    {0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F},
    // [ \ ] ^ _
    {0x0E, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0E},
    {0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x00},
    {0x0E, 0x02, 0x02, 0x02, 0x02, 0x02, 0x0E},
    {0x04, 0x0A, 0x11, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F},
};

} // namespace

uint16_t TextDecoder::cellAddress(uint16_t pageBase, int row, int col) {
    if (row < 0 || row >= kRows || col < 0 || col >= kCols) {
        return pageBase;
    }
    return static_cast<uint16_t>(pageBase + ((row & 7) << 7) + ((row >> 3) * 40) + col);
}

void TextDecoder::decodeScreen(const uint8_t *ram, uint16_t pageBase,
                               uint8_t out40x24[kRows * kCols]) {
    for (int row = 0; row < kRows; ++row) {
        for (int col = 0; col < kCols; ++col) {
            const uint16_t addr = cellAddress(pageBase, row, col);
            out40x24[row * kCols + col] = ram[addr];
        }
    }
}

void TextDecoder::writeTextScreen(uint8_t *ram, uint16_t pageBase, const char *text, int startRow,
                                  int startCol) {
    int row = startRow;
    int col = startCol;
    for (const char *p = text; *p; ++p) {
        if (*p == '\n') {
            ++row;
            col = startCol;
            if (row >= kRows) {
                break;
            }
            continue;
        }
        if (row < 0 || row >= kRows || col < 0 || col >= kCols) {
            continue;
        }
        char ch = *p;
        if (ch >= 'a' && ch <= 'z') {
            ch = static_cast<char>(ch - 'a' + 'A');
        }
        ram[cellAddress(pageBase, row, col)] =
            static_cast<uint8_t>(static_cast<uint8_t>(ch) | 0x80u);
        ++col;
        if (col >= kCols) {
            col = 0;
            ++row;
            if (row >= kRows) {
                break;
            }
        }
    }
}

uint8_t TextDecoder::glyphRow(uint8_t ascii7, int row) {
    if (row < 0 || row >= kGlyphH) {
        return 0;
    }
    uint8_t c = ascii7 & 0x7Fu;
    if (c < 0x20 || c > 0x5F) {
        c = static_cast<uint8_t>('?');
    }
    return kGlyphs[c - 0x20][row];
}

void TextDecoder::renderRgb888(const uint8_t chars40x24[kRows * kCols], uint8_t *rgbOut,
                               size_t rgbBytes, uint8_t fgR, uint8_t fgG, uint8_t fgB, uint8_t bgR,
                               uint8_t bgG, uint8_t bgB) {
    const size_t need = static_cast<size_t>(kRgbW * kRgbH * 3);
    if (!rgbOut || rgbBytes < need) {
        return;
    }
    for (int py = 0; py < kRgbH; ++py) {
        const int row = py / kCellH;
        const int gy = py % kCellH;
        for (int px = 0; px < kRgbW; ++px) {
            const int col = px / kCellW;
            const int gx = px % kCellW;
            const uint8_t cell = chars40x24[row * kCols + col];
            const uint8_t ascii7 = cell & 0x7Fu;
            const bool inverse = (cell & 0x80u) == 0;
            bool on = false;
            if (gy < kGlyphH && gx < kGlyphW) {
                const uint8_t bits = glyphRow(ascii7, gy);
                on = (bits & (1u << (kGlyphW - 1 - gx))) != 0;
            }
            if (inverse) {
                on = !on;
            }
            uint8_t *p = rgbOut + (static_cast<size_t>(py) * kRgbW + px) * 3;
            if (on) {
                p[0] = fgR;
                p[1] = fgG;
                p[2] = fgB;
            } else {
                p[0] = bgR;
                p[1] = bgG;
                p[2] = bgB;
            }
        }
    }
}

} // namespace esp_bracket
